## boards/shields/vamsi/Kconfig.defconfig
```kconfig
if SHIELD_VAMSI

config ZMK_KEYBOARD_NAME
    default "vamsi"

endif # SHIELD_VAMSI
```
